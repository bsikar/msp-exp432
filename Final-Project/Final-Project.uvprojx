# Keil uVision project Final-Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final-Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source Group 1
    ./: adc_helper.c adc_helper.h lab_tasks.c lab_tasks.h lab_tasks_helper.c lab_tasks_helper.h main.c uart_helper.c uart_helper.h
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.2
